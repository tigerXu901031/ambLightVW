# Keil uVision project ambLight.uvproj, settings and files
target Target 1 (166/167)
  device: XC2267-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0FFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: ambLight
  group app
    ../src/app/: ledCtrl.c ledCtrl.h main.c task.c task.h
  group srv
    ../src/srv/: generic.h led.c led.h type.h linSrv.c linSrv.h
  group drv
    ../src/drv/: io.c io.h XC22xxLREGS.H clk.c clk.h scs.c scs.h linCfg.h linDrv.c linDrv.h START_V3.A66
